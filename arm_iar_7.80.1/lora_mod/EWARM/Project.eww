<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\lora_mod.ewp</path>
  </project>
  <batchBuild />
</workspace>
